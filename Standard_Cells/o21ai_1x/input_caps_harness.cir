Test Harness  for sky130_vsdo21ai_1x
.include 'sky130nm.lib'
.include 'custom_stdcell/o21ai_1x/sky130_vsdo21ai_1x.spice'
    .options savecurrents
    X1 A1 A2 B1 VGND VNB VPB VPWR Y sky130_vsdo21ai_1x
    * Power Supplies
    VVPWR VPWR 0 DC 1.8
VVPB VPB 0 DC 1.8
VVGND VGND 0 DC 0
VVNB VNB 0 DC 0
    * Signal Supplies
    VB1 B1 0 PULSE(0 1.8 0 0.01n 0.01n 50ns 100ns)
VA1 A1 0 DC 0
VA2 A2 0 DC 1.8
    * CLoad
    CLoad Y 0 1f
    * Control Generations
    .control
    foreach case 1.8 0
    if $case=0
        * Fall Condition
        reset
        alter @VB1[PWL] = [ 0 1.8 1.25n 0.9 2.5n 0 ]
        tran 0.01n 2.5n
        run
        let fall_caps = abs(avg(vB1#branch))*2.5n/(1.8)
        let fall_cap = fall_caps[length(fall_caps)-1]/1p
        echo "B1:fall_capacitance:$&fall_cap" >> custom_stdcell/o21ai_1x/data/input_caps/input_pins_caps.txt
    else
        * Rise Condition
        reset
        alter @VB1[PWL] = [ 0ns 0 1.25ns 0.9 2.5ns 1.8 ]
        tran 0.01n 2.5n
        run
        let rise_caps = abs(avg(vB1#branch))*2.5n/(1.8)
        let rise_cap = rise_caps[length(rise_caps)-1]/1p
        echo "B1:rise_capacitance:$&rise_cap" >> custom_stdcell/o21ai_1x/data/input_caps/input_pins_caps.txt
    end
    end
    rusage
    quit
    .endc
