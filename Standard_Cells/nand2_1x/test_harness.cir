Test Harness for verifying nand2.spice

.include '../../sky130nm.lib'
.include 'sky130_vsdnand2_1x.spice'

X1 A B VGND VPWR VPWR Y sky130_vsdnand2_1x

* Supplies
VVGND VGND 0 0
VVPWR VPWR VGND DC 1.8
* Input Pulse
VA A VGND PULSE 0 1.8 0 1n 1n 50ns 100ns
VB B VGND PULSE 0 1.8 1.1n 1n 1n 25ns 50ns

CLOAD Y VGND 0.05p

.control
tran 0.1n 100ns
run
plot a
plot b
plot y
.endc
