Test Harness  for sky130_vsdnand3_1x
.include 'sky130nm.lib'
.include 'custom_stdcell/nand3_1x/sky130_vsdnand3_1x.spice'
    .options savecurrents
    X1 A B C VGND VNB VPB VPWR Y sky130_vsdnand3_1x
    * Power Supplies
    VVPWR VPWR 0 DC 1.8
VVPB VPB 0 DC 1.8
VVGND VGND 0 DC 0
VVNB VNB 0 DC 0
    * Signal Supplies
    VC C 0 PULSE(0 1.8 0 0.01n 0.01n 50ns 100ns)
VA A 0 DC 1.8
VB B 0 DC 1.8
    * CLoad
    CLoad Y 0 1f
    * Control Generations
    .control
    foreach case 1.8 0
    if $case=0
        * Fall Condition
        reset
        alter @VC[PWL] = [ 0 1.8 1.25n 0.9 2.5n 0 ]
        tran 0.01n 2.5n
        run
        let fall_caps = abs(avg(vC#branch))*2.5n/(1.8)
        let fall_cap = fall_caps[length(fall_caps)-1]/1p
        echo "C:fall_capacitance:$&fall_cap" >> custom_stdcell/nand3_1x/data/input_caps/input_pins_caps.txt
    else
        * Rise Condition
        reset
        alter @VC[PWL] = [ 0ns 0 1.25ns 0.9 2.5ns 1.8 ]
        tran 0.01n 2.5n
        run
        let rise_caps = abs(avg(vC#branch))*2.5n/(1.8)
        let rise_cap = rise_caps[length(rise_caps)-1]/1p
        echo "C:rise_capacitance:$&rise_cap" >> custom_stdcell/nand3_1x/data/input_caps/input_pins_caps.txt
    end
    end
    rusage
    quit
    .endc
